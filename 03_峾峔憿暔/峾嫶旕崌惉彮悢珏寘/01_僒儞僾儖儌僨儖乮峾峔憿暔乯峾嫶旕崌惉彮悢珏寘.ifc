Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: example_small.ifc
Time: 2014-05-18T19:42:21
Author: Architect
Organization: Building Designer Office
Written by: IFC Engine DLL version 1.02 beta
Made in: IFC Engine DLL version 1.02 beta
Authorization: The authorising person

# IfcProject, Project
Description: 施主、路線名等

# IfcSite, Site
Description: 場所

# IfcBuilding (2)
Name | In | Description
Build |  | 工事名
*** KANSEI KEI ***NISHI-KANIDA | Build | モデル名

# IfcBuildingStorey, *** KANSEI KEI ***NISHI-KANIDA
In: *** KANSEI KEI ***NISHI-KANIDA
Description: モデル名

# IfcBuildingElementProxy (2781)
In: *** KANSEI KEI ***NISHI-KANIDA
Name
主桁
3 x G1
3 x B19
2 x U119
鋼板 | BaseQuantities - NetSideArea: 14.622 m2; NetVolume: 0.36 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 53.0; 重量: 2830.20; 幅: 750.00; 長さ: 9070.05
3 x W119
鋼板 | BaseQuantities - NetSideArea: 52.032 m2; NetVolume: 0.438 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 3445.68; 幅: 2874.20; 長さ: 9070.01
H35
250 x 1
鋼板 | BaseQuantities - NetSideArea: 0.256 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 13.53; 幅: 170.00; 長さ: 761.00
H36
鋼板 | BaseQuantities - NetSideArea: 0.44 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 23.32; 幅: 170.00; 長さ: 1410.00
H37
鋼板 | BaseQuantities - NetSideArea: 0.443 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 23.46; 幅: 170.00; 長さ: 1417.00
H38
鋼板 | BaseQuantities - NetSideArea: 0.439 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 23.28; 幅: 170.00; 長さ: 1408.00
H39
2 x 鋼板 | BaseQuantities - NetSideArea: 0.24 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 12.47; 幅: 170.00; 長さ: 868.00
51 x 2
H40
鋼板 | BaseQuantities - NetSideArea: 0.23 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 12.09; 幅: 170.00; 長さ: 689.00
V29
鋼板 | BaseQuantities - NetSideArea: 2.658 m2; NetVolume: 0.05 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 393.27; 幅: 420.00; 長さ: 2847.00
4 x 鋼板 | BaseQuantities - NetSideArea: 2.657 m2; NetVolume: 0.05 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 393.27; 幅: 420.00; 長さ: 2847.00
30 x 3
21 x 4
8 x 5
V30
4 x 鋼板 | BaseQuantities - NetSideArea: 1.563 m2; NetVolume: 0.022 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 171.58; 幅: 240.00; 長さ: 2847.00
V31
2 x 鋼板 | BaseQuantities - NetSideArea: 0.981 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 46.09; 幅: 160.00; 長さ: 2847.00
V32
鋼板 | BaseQuantities - NetSideArea: 2.155 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 217.27; 幅: 350.00; 長さ: 2847.00
2 x L119
鋼板 | BaseQuantities - NetSideArea: 14.778 m2; NetVolume: 0.414 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 61.0; 重量: 3257.39; 幅: 750.00; 長さ: 9070.05
3 x B20
2 x U120
鋼板 | BaseQuantities - NetSideArea: 12.472 m2; NetVolume: 0.241 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 41.0; 重量: 1894.90; 幅: 750.00; 長さ: 7850.04
3 x W120
鋼板 | BaseQuantities - NetSideArea: 45.197 m2; NetVolume: 0.335 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 15.0; 重量: 2642.30; 幅: 2882.50; 長さ: 7850.01
2 x H31
2 x 鋼板 | BaseQuantities - NetSideArea: 0.233 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 12.27; 幅: 170.00; 長さ: 698.00
2 x H29
2 x 鋼板 | BaseQuantities - NetSideArea: 0.442 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 23.42; 幅: 170.00; 長さ: 1415.00
2 x H28
2 x 鋼板 | BaseQuantities - NetSideArea: 0.44 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 23.30; 幅: 170.00; 長さ: 1409.00
H27
鋼板 | BaseQuantities - NetSideArea: 0.492 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 26.13; 幅: 170.00; 長さ: 1550.00
H26
鋼板 | BaseQuantities - NetSideArea: 0.495 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 26.27; 幅: 170.00; 長さ: 1557.00
H41
鋼板 | BaseQuantities - NetSideArea: 0.259 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 13.69; 幅: 170.00; 長さ: 769.00
2 x V33
6 x 鋼板 | BaseQuantities - NetSideArea: 1.17 m2; NetVolume: 0.008 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 63.50; 幅: 190.00; 長さ: 2859.00
V34
2 x 鋼板 | BaseQuantities - NetSideArea: 0.985 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 46.28; 幅: 160.00; 長さ: 2859.00
2 x V35
2 x 鋼板 | BaseQuantities - NetSideArea: 2.164 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 218.19; 幅: 350.00; 長さ: 2859.00
2 x L120
2 x 鋼板 | BaseQuantities - NetSideArea: 12.585 m2; NetVolume: 0.282 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 48.0; 重量: 2218.42; 幅: 750.00; 長さ: 7850.04
3 x B21
2 x U121
2 x 鋼板 | BaseQuantities - NetSideArea: 12.837 m2; NetVolume: 0.185 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 30.0; 重量: 1448.33; 幅: 750.00; 長さ: 8200.04
3 x W121
鋼板 | BaseQuantities - NetSideArea: 47.371 m2; NetVolume: 0.329 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2586.01; 幅: 2894.60; 長さ: 8200.00
3 x V17
3 x 鋼板 | BaseQuantities - NetSideArea: 2.172 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 219.04; 幅: 350.00; 長さ: 2870.00
2 x L121
鋼板 | BaseQuantities - NetSideArea: 12.799 m2; NetVolume: 0.172 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 28.0; 重量: 1351.78; 幅: 750.00; 長さ: 8200.04
3 x B22
2 x U122
鋼板 | BaseQuantities - NetSideArea: 12.889 m2; NetVolume: 0.203 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 33.0; 重量: 1593.16; 幅: 750.00; 長さ: 8200.04
3 x W122
2 x 鋼板 | BaseQuantities - NetSideArea: 47.324 m2; NetVolume: 0.329 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2583.43; 幅: 2891.60; 長さ: 8200.00
2 x V16
2 x 鋼板 | BaseQuantities - NetSideArea: 2.111 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 212.84; 幅: 350.00; 長さ: 2767.00
2 x L122
鋼板 | BaseQuantities - NetSideArea: 12.748 m2; NetVolume: 0.154 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 25.0; 重量: 1206.94; 幅: 750.00; 長さ: 8200.04
3 x B23
2 x U123
鋼板 | BaseQuantities - NetSideArea: 12.889 m2; NetVolume: 0.203 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 33.0; 重量: 1593.16; 幅: 750.00; 長さ: 8200.03
3 x W123
2 x L123
鋼板 | BaseQuantities - NetSideArea: 12.748 m2; NetVolume: 0.154 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 25.0; 重量: 1206.94; 幅: 750.00; 長さ: 8200.03
3 x B24
2 x U124
3 x W124
鋼板 | BaseQuantities - NetSideArea: 47.373 m2; NetVolume: 0.329 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2586.10; 幅: 2894.40; 長さ: 8200.00
2 x L124
鋼板 | BaseQuantities - NetSideArea: 12.765 m2; NetVolume: 0.16 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 26.0; 重量: 1255.22; 幅: 750.00; 長さ: 8200.04
3 x B25
2 x U125
鋼板 | BaseQuantities - NetSideArea: 12.291 m2; NetVolume: 0.177 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM570; 部材形状: PL; 板厚: 30.0; 重量: 1386.51; 幅: 750.00; 長さ: 7850.04
3 x W125
鋼板 | BaseQuantities - NetSideArea: 45.391 m2; NetVolume: 0.361 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM570; 部材形状: PL; 板厚: 16.0; 重量: 2829.33; 幅: 2892.20; 長さ: 7850.01
H42
鋼板 | BaseQuantities - NetSideArea: 0.263 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 15.52; 幅: 170.00; 長さ: 769.00
H43
鋼板 | BaseQuantities - NetSideArea: 0.501 m2; NetVolume: 0.004 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 29.77; 幅: 170.00; 長さ: 1557.00
H44
鋼板 | BaseQuantities - NetSideArea: 0.498 m2; NetVolume: 0.004 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 29.61; 幅: 170.00; 長さ: 1550.00
5 x H21
5 x 鋼板 | BaseQuantities - NetSideArea: 0.445 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 26.41; 幅: 170.00; 長さ: 1409.00
5 x H16
5 x 鋼板 | BaseQuantities - NetSideArea: 0.448 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 26.55; 幅: 170.00; 長さ: 1415.00
2 x H45
2 x 鋼板 | BaseQuantities - NetSideArea: 0.236 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 13.91; 幅: 170.00; 長さ: 698.00
V36
2 x 鋼板 | BaseQuantities - NetSideArea: 0.989 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 46.46; 幅: 160.00; 長さ: 2870.00
V37
2 x 鋼板 | BaseQuantities - NetSideArea: 1.174 m2; NetVolume: 0.008 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 63.75; 幅: 190.00; 長さ: 2870.00
2 x L125
鋼板 | BaseQuantities - NetSideArea: 12.403 m2; NetVolume: 0.218 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM570; 部材形状: PL; 板厚: 37.0; 重量: 1710.03; 幅: 750.00; 長さ: 7850.04
3 x B26
2 x U126
鋼板 | BaseQuantities - NetSideArea: 14.398 m2; NetVolume: 0.266 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM570; 部材形状: PL; 板厚: 39.0; 重量: 2088.33; 幅: 750.00; 長さ: 9095.03
3 x W126
鋼板 | BaseQuantities - NetSideArea: 52.435 m2; NetVolume: 0.441 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM570; 部材形状: PL; 板厚: 17.0; 重量: 3472.16; 幅: 2885.00; 長さ: 9095.00
2 x H46
3 x 鋼板 | BaseQuantities - NetSideArea: 0.233 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 13.70; 幅: 170.00; 長さ: 689.00
3 x H47
6 x 鋼板 | BaseQuantities - NetSideArea: 0.243 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 14.14; 幅: 170.00; 長さ: 868.00
3 x H17
3 x 鋼板 | BaseQuantities - NetSideArea: 0.445 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 26.37; 幅: 170.00; 長さ: 1407.00
2 x H48
2 x 鋼板 | BaseQuantities - NetSideArea: 0.269 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 15.90; 幅: 170.00; 長さ: 786.00
V38
5 x 鋼板 | BaseQuantities - NetSideArea: 2.67 m2; NetVolume: 0.05 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 395.21; 幅: 420.00; 長さ: 2861.00
V39
4 x 鋼板 | BaseQuantities - NetSideArea: 1.571 m2; NetVolume: 0.022 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 172.43; 幅: 240.00; 長さ: 2861.00
V40
V41
2 x 鋼板 | BaseQuantities - NetSideArea: 1.171 m2; NetVolume: 0.008 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 63.55; 幅: 190.00; 長さ: 2861.00
V42
V43
鋼板 | BaseQuantities - NetSideArea: 2.165 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 218.35; 幅: 350.00; 長さ: 2861.00
2 x L126
鋼板 | BaseQuantities - NetSideArea: 14.511 m2; NetVolume: 0.306 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM570-H; 部材形状: PL; 板厚: 45.0; 重量: 2409.62; 幅: 750.00; 長さ: 9095.03
3 x B27
2 x U127
2 x 鋼板 | BaseQuantities - NetSideArea: 13.245 m2; NetVolume: 0.196 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 31.0; 重量: 1542.23; 幅: 750.00; 長さ: 8450.02
3 x W127
鋼板 | BaseQuantities - NetSideArea: 48.815 m2; NetVolume: 0.362 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 15.0; 重量: 2854.20; 幅: 2889.70; 長さ: 8450.00
6 x H49
22 x 鋼板 | BaseQuantities - NetSideArea: 0.513 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 27.27; 幅: 170.00; 長さ: 1607.00
4 x H50
6 x 鋼板 | BaseQuantities - NetSideArea: 0.51 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 27.13; 幅: 170.00; 長さ: 1600.00
2 x H51
2 x 鋼板 | BaseQuantities - NetSideArea: 0.266 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 14.03; 幅: 170.00; 長さ: 786.00
2 x H52
2 x 鋼板 | BaseQuantities - NetSideArea: 0.268 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 14.19; 幅: 170.00; 長さ: 794.00
2 x V44
8 x 鋼板 | BaseQuantities - NetSideArea: 0.989 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 46.44; 幅: 160.00; 長さ: 2869.00
2 x V45
3 x 鋼板 | BaseQuantities - NetSideArea: 2.171 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 218.96; 幅: 350.00; 長さ: 2869.00
2 x L127
鋼板 | BaseQuantities - NetSideArea: 13.209 m2; NetVolume: 0.184 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 29.0; 重量: 1442.74; 幅: 750.00; 長さ: 8450.02
3 x B28
2 x U128
鋼板 | BaseQuantities - NetSideArea: 13.387 m2; NetVolume: 0.247 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 39.0; 重量: 1940.23; 幅: 750.00; 長さ: 8450.02
3 x W128
鋼板 | BaseQuantities - NetSideArea: 48.662 m2; NetVolume: 0.338 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2656.60; 幅: 2880.20; 長さ: 8450.00
V46
鋼板 | BaseQuantities - NetSideArea: 2.107 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 212.38; 幅: 350.00; 長さ: 2761.00
2 x L128
鋼板 | BaseQuantities - NetSideArea: 13.385 m2; NetVolume: 0.247 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 39.0; 重量: 1940.23; 幅: 750.00; 長さ: 8450.02
3 x B29
2 x U129
鋼板 | BaseQuantities - NetSideArea: 13.444 m2; NetVolume: 0.266 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 2089.48; 幅: 750.00; 長さ: 8450.03
3 x W129
鋼板 | BaseQuantities - NetSideArea: 48.612 m2; NetVolume: 0.338 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2653.84; 幅: 2875.60; 長さ: 8450.01
V47
鋼板 | BaseQuantities - NetSideArea: 2.104 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 212.15; 幅: 350.00; 長さ: 2758.00
2 x L129
鋼板 | BaseQuantities - NetSideArea: 13.444 m2; NetVolume: 0.266 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 2089.48; 幅: 750.00; 長さ: 8450.03
3 x B30
2 x U130
鋼板 | BaseQuantities - NetSideArea: 13.405 m2; NetVolume: 0.253 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 40.0; 重量: 1989.98; 幅: 750.00; 長さ: 8450.01
3 x W130
鋼板 | BaseQuantities - NetSideArea: 48.646 m2; NetVolume: 0.338 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2655.68; 幅: 2876.10; 長さ: 8450.00; 孔数: 10
4 x Bolt孔 | Bolt Hole Numbers - 孔径24.5: 10
2 x H53
2 x 鋼板 | BaseQuantities - NetSideArea: 0.268 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 14.17; 幅: 170.00; 長さ: 793.00
H54
2 x 鋼板 | BaseQuantities - NetSideArea: 0.266 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 14.03; 幅: 170.00; 長さ: 786.00; 孔数: 3
16 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 3
H12
12 x 鋼板 | BaseQuantities - NetSideArea: 0.07 m2; NetVolume: 0 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 12.0; 重量: 2.88; 幅: 140.00; 長さ: 230.00; 孔数: 3
V48
4 x 鋼板 | BaseQuantities - NetSideArea: 0.955 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 44.86; 幅: 160.00; 長さ: 2760.00
V49
鋼板 | BaseQuantities - NetSideArea: 2.106 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 212.30; 幅: 350.00; 長さ: 2760.00
2 x L130
鋼板 | BaseQuantities - NetSideArea: 13.398 m2; NetVolume: 0.253 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 40.0; 重量: 1989.98; 幅: 750.00; 長さ: 8450.01
6 x B31
2 x U131
鋼板 | BaseQuantities - NetSideArea: 12.881 m2; NetVolume: 0.197 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 1545.82; 幅: 750.00; 長さ: 8205.02
4 x W131
鋼板 | BaseQuantities - NetSideArea: 47.171 m2; NetVolume: 0.328 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2575.03; 幅: 2882.20; 長さ: 8205.00; 孔数: 10
H55
2 x 鋼板 | BaseQuantities - NetSideArea: 0.268 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 14.19; 幅: 170.00; 長さ: 794.00; 孔数: 3
2 x H56
2 x 鋼板 | BaseQuantities - NetSideArea: 0.206 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 10.65; 幅: 170.00; 長さ: 777.00
H8
V50
4 x 鋼板 | BaseQuantities - NetSideArea: 2.096 m2; NetVolume: 0.03 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 237.69; 幅: 330.00; 長さ: 2868.00
V51
2 x 鋼板 | BaseQuantities - NetSideArea: 1.525 m2; NetVolume: 0.017 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 24.0; 重量: 129.64; 幅: 240.00; 長さ: 2868.00
V52
4 x 鋼板 | BaseQuantities - NetSideArea: 0.992 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 46.63; 幅: 160.00; 長さ: 2868.00
主桁添接板
HJ1
4 x 鋼板 | BaseQuantities - NetSideArea: 0.118 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 水平補剛材添接板_W; 材質: SS400; 部材形状: PL; 板厚: 11.0; 重量: 4.56; 幅: 120.00; 長さ: 440.00; 孔数: 6
26 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 6
HJ2
12 x 鋼板 | BaseQuantities - NetSideArea: 0.09 m2; NetVolume: 0 m3; Steel Quantities - 部材種類: 水平補剛材添接板_W; 材質: SS400; 部材形状: PL; 板厚: 12.0; 重量: 3.62; 幅: 80.00; 長さ: 480.00; 孔数: 6
2 x 6
2 x L131
鋼板 | BaseQuantities - NetSideArea: 12.565 m2; NetVolume: 0.14 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 23.0; 重量: 1097.52; 幅: 750.00; 長さ: 8105.02; 孔数: 8
4 x Bolt孔 | Bolt Hole Numbers - 孔径42.0: 8
SL3
2 x 鋼板 | BaseQuantities - NetSideArea: 1.54 m2; NetVolume: 0.024 m3; Steel Quantities - 部材種類: G_ソールプレート; 材質: SM490B; 部材形状: PL; 板厚: 35.0; 重量: 188.40; 幅: 700.00; 長さ: 1050.00; 孔数: 8
BS4
2 x 鋼板 | BaseQuantities - NetSideArea: 0.544 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: G_沓座ベースプレート; 材質: SM400A; 部材形状: PL; 板厚: 25.0; 重量: 49.06; 幅: 500.00; 長さ: 500.00
3 x G2
2 x U219
鋼板 | BaseQuantities - NetSideArea: 14.42 m2; NetVolume: 0.285 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM570-H; 部材形状: PL; 板厚: 42.0; 重量: 2242.80; 幅: 750.00; 長さ: 9070.05
2 x W219
鋼板 | BaseQuantities - NetSideArea: 52.24 m2; NetVolume: 0.441 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM570; 部材形状: PL; 板厚: 17.0; 重量: 3458.99; 幅: 2885.20; 長さ: 9070.01
H73
鋼板 | BaseQuantities - NetSideArea: 0.26 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 15.33; 幅: 170.00; 長さ: 761.00
H74
V20
鋼板 | BaseQuantities - NetSideArea: 2.163 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 218.11; 幅: 350.00; 長さ: 2858.00
V79
5 x 鋼板 | BaseQuantities - NetSideArea: 2.668 m2; NetVolume: 0.05 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 394.79; 幅: 420.00; 長さ: 2858.00
V80
4 x 鋼板 | BaseQuantities - NetSideArea: 1.569 m2; NetVolume: 0.022 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 172.25; 幅: 240.00; 長さ: 2858.00
V19
2 x 鋼板 | BaseQuantities - NetSideArea: 1.169 m2; NetVolume: 0.008 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 63.48; 幅: 190.00; 長さ: 2858.00
2 x L219
鋼板 | BaseQuantities - NetSideArea: 14.552 m2; NetVolume: 0.333 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM570-H; 部材形状: PL; 板厚: 49.0; 重量: 2616.60; 幅: 750.00; 長さ: 9070.05
2 x U220
鋼板 | BaseQuantities - NetSideArea: 12.474 m2; NetVolume: 0.241 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 41.0; 重量: 1894.90; 幅: 750.00; 長さ: 7850.04
2 x W220
鋼板 | BaseQuantities - NetSideArea: 45.238 m2; NetVolume: 0.381 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 2994.72; 幅: 2882.50; 長さ: 7850.01
H34
2 x 鋼板 | BaseQuantities - NetSideArea: 0.259 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 13.67; 幅: 170.00; 長さ: 768.00
H75
鋼板 | BaseQuantities - NetSideArea: 0.491 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 26.11; 幅: 170.00; 長さ: 1549.00
H76
鋼板 | BaseQuantities - NetSideArea: 0.494 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 26.23; 幅: 170.00; 長さ: 1555.00
2 x L220
2 x U221
鋼板 | BaseQuantities - NetSideArea: 12.873 m2; NetVolume: 0.197 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 1544.89; 幅: 750.00; 長さ: 8200.04
2 x W221
鋼板 | BaseQuantities - NetSideArea: 47.339 m2; NetVolume: 0.329 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2584.24; 幅: 2892.60; 長さ: 8200.00
V9
鋼板 | BaseQuantities - NetSideArea: 2.17 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 218.88; 幅: 350.00; 長さ: 2868.00
2 x L221
鋼板 | BaseQuantities - NetSideArea: 12.801 m2; NetVolume: 0.172 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 28.0; 重量: 1351.78; 幅: 750.00; 長さ: 8200.04
2 x U222
鋼板 | BaseQuantities - NetSideArea: 12.907 m2; NetVolume: 0.209 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 34.0; 重量: 1641.44; 幅: 750.00; 長さ: 8200.04
2 x W222
2 x 鋼板 | BaseQuantities - NetSideArea: 47.307 m2; NetVolume: 0.329 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2582.52; 幅: 2890.60; 長さ: 8200.00
2 x V26
2 x 鋼板 | BaseQuantities - NetSideArea: 2.11 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 212.76; 幅: 350.00; 長さ: 2766.00
2 x L222
鋼板 | BaseQuantities - NetSideArea: 12.818 m2; NetVolume: 0.178 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 29.0; 重量: 1400.05; 幅: 750.00; 長さ: 8200.04
2 x U223
鋼板 | BaseQuantities - NetSideArea: 12.907 m2; NetVolume: 0.209 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 34.0; 重量: 1641.44; 幅: 750.00; 長さ: 8200.03
2 x W223
2 x L223
鋼板 | BaseQuantities - NetSideArea: 12.818 m2; NetVolume: 0.178 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 29.0; 重量: 1400.05; 幅: 750.00; 長さ: 8200.03
2 x U224
鋼板 | BaseQuantities - NetSideArea: 12.855 m2; NetVolume: 0.191 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 31.0; 重量: 1496.61; 幅: 750.00; 長さ: 8200.04
2 x W224
鋼板 | BaseQuantities - NetSideArea: 47.356 m2; NetVolume: 0.329 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2585.18; 幅: 2893.40; 長さ: 8200.00
V81
2 x L224
鋼板 | BaseQuantities - NetSideArea: 12.783 m2; NetVolume: 0.166 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 27.0; 重量: 1303.50; 幅: 750.00; 長さ: 8200.04
2 x U225
鋼板 | BaseQuantities - NetSideArea: 12.358 m2; NetVolume: 0.2 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM570; 部材形状: PL; 板厚: 34.0; 重量: 1571.38; 幅: 750.00; 長さ: 7850.04
2 x W225
鋼板 | BaseQuantities - NetSideArea: 45.346 m2; NetVolume: 0.382 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM570; 部材形状: PL; 板厚: 17.0; 重量: 3001.94; 幅: 2888.20; 長さ: 7850.01
H77
鋼板 | BaseQuantities - NetSideArea: 0.262 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 15.49; 幅: 170.00; 長さ: 768.00
H23
鋼板 | BaseQuantities - NetSideArea: 0.5 m2; NetVolume: 0.004 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 29.72; 幅: 170.00; 長さ: 1555.00
H22
鋼板 | BaseQuantities - NetSideArea: 0.498 m2; NetVolume: 0.004 m3; Steel Quantities - 部材種類: 水平補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 17.0; 重量: 29.59; 幅: 170.00; 長さ: 1549.00
V27
鋼板 | BaseQuantities - NetSideArea: 2.169 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 218.73; 幅: 350.00; 長さ: 2866.00
V82
4 x 鋼板 | BaseQuantities - NetSideArea: 1.173 m2; NetVolume: 0.008 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 63.66; 幅: 190.00; 長さ: 2866.00
2 x L225
鋼板 | BaseQuantities - NetSideArea: 12.437 m2; NetVolume: 0.229 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM570; 部材形状: PL; 板厚: 39.0; 重量: 1802.47; 幅: 750.00; 長さ: 7850.04
2 x U226
鋼板 | BaseQuantities - NetSideArea: 14.528 m2; NetVolume: 0.313 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM570-H; 部材形状: PL; 板厚: 46.0; 重量: 2463.16; 幅: 750.00; 長さ: 9095.03
2 x W226
鋼板 | BaseQuantities - NetSideArea: 52.311 m2; NetVolume: 0.441 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM570; 部材形状: PL; 板厚: 17.0; 重量: 3463.67; 幅: 2878.00; 長さ: 9095.00
V83
鋼板 | BaseQuantities - NetSideArea: 2.16 m2; NetVolume: 0.028 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 217.81; 幅: 350.00; 長さ: 2854.00
V84
5 x 鋼板 | BaseQuantities - NetSideArea: 2.664 m2; NetVolume: 0.05 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 394.24; 幅: 420.00; 長さ: 2854.00
V11
4 x 鋼板 | BaseQuantities - NetSideArea: 1.567 m2; NetVolume: 0.022 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 172.01; 幅: 240.00; 長さ: 2854.00
V85
V86
2 x 鋼板 | BaseQuantities - NetSideArea: 1.168 m2; NetVolume: 0.008 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 15.0; 重量: 63.39; 幅: 190.00; 長さ: 2854.00
V87
2 x L226
鋼板 | BaseQuantities - NetSideArea: 14.641 m2; NetVolume: 0.354 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM570-H; 部材形状: PL; 板厚: 52.0; 重量: 2784.44; 幅: 750.00; 長さ: 9095.03
2 x U227
2 x W227
鋼板 | BaseQuantities - NetSideArea: 48.813 m2; NetVolume: 0.362 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 15.0; 重量: 2854.10; 幅: 2889.70; 長さ: 8450.00
2 x L227
鋼板 | BaseQuantities - NetSideArea: 13.264 m2; NetVolume: 0.203 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 1591.98; 幅: 750.00; 長さ: 8450.02
2 x U228
鋼板 | BaseQuantities - NetSideArea: 13.457 m2; NetVolume: 0.272 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 43.0; 重量: 2139.23; 幅: 750.00; 長さ: 8450.02
2 x W228
鋼板 | BaseQuantities - NetSideArea: 48.595 m2; NetVolume: 0.338 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2652.88; 幅: 2876.20; 長さ: 8450.00
V88
鋼板 | BaseQuantities - NetSideArea: 2.103 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 212.07; 幅: 350.00; 長さ: 2757.00
2 x L228
鋼板 | BaseQuantities - NetSideArea: 13.458 m2; NetVolume: 0.272 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 43.0; 重量: 2139.23; 幅: 750.00; 長さ: 8450.02
2 x U229
鋼板 | BaseQuantities - NetSideArea: 13.518 m2; NetVolume: 0.292 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 46.0; 重量: 2288.48; 幅: 750.00; 長さ: 8450.03
2 x W229
鋼板 | BaseQuantities - NetSideArea: 48.544 m2; NetVolume: 0.338 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2650.13; 幅: 2871.60; 長さ: 8450.01
V89
鋼板 | BaseQuantities - NetSideArea: 2.101 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 211.84; 幅: 350.00; 長さ: 2754.00
2 x L229
鋼板 | BaseQuantities - NetSideArea: 13.518 m2; NetVolume: 0.292 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 46.0; 重量: 2288.48; 幅: 750.00; 長さ: 8450.03
2 x U230
鋼板 | BaseQuantities - NetSideArea: 13.477 m2; NetVolume: 0.279 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 44.0; 重量: 2188.98; 幅: 750.00; 長さ: 8450.01
2 x W230
鋼板 | BaseQuantities - NetSideArea: 48.578 m2; NetVolume: 0.338 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2651.96; 幅: 2872.10; 長さ: 8450.00; 孔数: 10
H78
H58
V90
鋼板 | BaseQuantities - NetSideArea: 2.103 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 28.0; 重量: 211.99; 幅: 350.00; 長さ: 2756.00
V91
4 x 鋼板 | BaseQuantities - NetSideArea: 0.954 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 44.80; 幅: 160.00; 長さ: 2756.00
2 x L230
鋼板 | BaseQuantities - NetSideArea: 13.469 m2; NetVolume: 0.278 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM520C-H; 部材形状: PL; 板厚: 44.0; 重量: 2188.98; 幅: 750.00; 長さ: 8450.01
2 x U231
鋼板 | BaseQuantities - NetSideArea: 12.899 m2; NetVolume: 0.203 m3; Steel Quantities - 部材種類: 上フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 33.0; 重量: 1594.13; 幅: 750.00; 長さ: 8205.02
4 x W231
鋼板 | BaseQuantities - NetSideArea: 47.154 m2; NetVolume: 0.328 m3; Steel Quantities - 部材種類: ウェブ; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 2574.11; 幅: 2881.20; 長さ: 8205.00; 孔数: 10
H79
H60
V92
4 x 鋼板 | BaseQuantities - NetSideArea: 2.096 m2; NetVolume: 0.03 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 237.61; 幅: 330.00; 長さ: 2867.00
V93
2 x 鋼板 | BaseQuantities - NetSideArea: 1.524 m2; NetVolume: 0.016 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM490YB; 部材形状: PL; 板厚: 24.0; 重量: 129.59; 幅: 240.00; 長さ: 2867.00
V94
4 x 鋼板 | BaseQuantities - NetSideArea: 0.992 m2; NetVolume: 0.006 m3; Steel Quantities - 部材種類: 垂直補剛材_W; 材質: SM400A; 部材形状: PL; 板厚: 13.0; 重量: 46.61; 幅: 160.00; 長さ: 2867.00
HJ5
HJ6
2 x L231
鋼板 | BaseQuantities - NetSideArea: 12.583 m2; NetVolume: 0.146 m3; Steel Quantities - 部材種類: 下フランジ; 材質: SM490YB; 部材形状: PL; 板厚: 24.0; 重量: 1145.24; 幅: 750.00; 長さ: 8105.02; 孔数: 8
SL5
BS6
3 x C95
58 x R1
FW195-1
3 x FW195
鋼板 | BaseQuantities - NetSideArea: 3.157 m2; NetVolume: 0.06 m3; Steel Quantities - 部材種類: 横桁; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 472.87; 幅: 586.31; 長さ: 2847.06
サブブロック
FW195-2
2 x 鋼板 | BaseQuantities - NetSideArea: 10.438 m2; NetVolume: 0.072 m3; Steel Quantities - 部材種類: 横桁; 材質: SM490YA; 部材形状: PL; 板厚: 14.0; 重量: 565.83; 幅: 1523.76; 長さ: 3590.38
FW195-3
鋼板 | BaseQuantities - NetSideArea: 3.167 m2; NetVolume: 0.06 m3; Steel Quantities - 部材種類: 横桁; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 474.39; 幅: 586.31; 長さ: 2858.06
3 x C96
FW196-1
3 x FW196
鋼板 | BaseQuantities - NetSideArea: 3.17 m2; NetVolume: 0.06 m3; Steel Quantities - 部材種類: 横桁; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 474.81; 幅: 586.31; 長さ: 2861.06
FW196-2
FW196-3
鋼板 | BaseQuantities - NetSideArea: 3.163 m2; NetVolume: 0.06 m3; Steel Quantities - 部材種類: 横桁; 材質: SM520C-H; 部材形状: PL; 板厚: 42.0; 重量: 473.84; 幅: 586.31; 長さ: 2854.06
6 x C97
2 x FW197-1
3 x FW197
鋼板 | BaseQuantities - NetSideArea: 2.629 m2; NetVolume: 0.039 m3; Steel Quantities - 部材種類: 横桁; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 303.25; 幅: 487.84; 長さ: 2868.00; 孔数: 30
6 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 30
FW197-2
鋼板 | BaseQuantities - NetSideArea: 12.61 m2; NetVolume: 0.087 m3; Steel Quantities - 部材種類: 横桁; 材質: SM400A; 部材形状: PL; 板厚: 14.0; 重量: 683.73; 幅: 1746.76; 長さ: 3790.31; 孔数: 60
5 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 60
FW197-3
鋼板 | BaseQuantities - NetSideArea: 2.628 m2; NetVolume: 0.039 m3; Steel Quantities - 部材種類: 横桁; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 303.17; 幅: 487.84; 長さ: 2867.00; 孔数: 30
サブ添接板
FWJ5
125 x F1
4 x 鋼板 | BaseQuantities - NetSideArea: 0.986 m2; NetVolume: 0.004 m3; Steel Quantities - 部材種類: 横桁添接板; 材質: SS400; 部材形状: PL; 板厚: 9.0; 重量: 33.64; 幅: 1543.78; 長さ: 310.00; 孔数: 60
FWJF9
4 x 鋼板 | BaseQuantities - NetSideArea: 0.491 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 横桁添接板; 材質: SS400; 部材形状: PL; 板厚: 9.0; 重量: 16.28; 幅: 1539.78; 長さ: 150.00; 孔数: 30
FWJ6
121 x B1
FWJF10
13 x F2
FWJF11
17 x B2
FWJF12
FU15
鋼板 | BaseQuantities - NetSideArea: 0.321 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 上フランジ_CB; 材質: SM490YB; 部材形状: PL; 板厚: 24.0; 重量: 36.81; 幅: 500.00; 長さ: 488.50; 孔数: 8
4 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 8
FU16
鋼板 | BaseQuantities - NetSideArea: 2.471 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 上フランジ_CB; 材質: SM400A; 部材形状: PL; 板厚: 24.0; 重量: 214.30; 幅: 300.00; 長さ: 3791.50; 孔数: 16
10 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 16
FU17
鋼板 | BaseQuantities - NetSideArea: 0.321 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 上フランジ_CB; 材質: SM490YB; 部材形状: PL; 板厚: 24.0; 重量: 36.78; 幅: 500.00; 長さ: 488.00; 孔数: 8
FL15
鋼板 | BaseQuantities - NetSideArea: 0.321 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 下フランジ_CB; 材質: SM490YB; 部材形状: PL; 板厚: 24.0; 重量: 36.74; 幅: 500.00; 長さ: 487.50; 孔数: 8
FL16
鋼板 | BaseQuantities - NetSideArea: 2.471 m2; NetVolume: 0.027 m3; Steel Quantities - 部材種類: 下フランジ_CB; 材質: SM400A; 部材形状: PL; 板厚: 24.0; 重量: 214.30; 幅: 300.00; 長さ: 3791.50; 孔数: 16
FL17
鋼板 | BaseQuantities - NetSideArea: 0.321 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 下フランジ_CB; 材質: SM490YB; 部材形状: PL; 板厚: 24.0; 重量: 36.78; 幅: 500.00; 長さ: 488.00; 孔数: 8
FUJ4
8 x 鋼板 | BaseQuantities - NetSideArea: 0.153 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 上フランジ添接板_CB; 材質: SS400; 部材形状: PL; 板厚: 16.0; 重量: 8.18; 幅: 105.00; 長さ: 620.00; 孔数: 8
112 x Bolt孔 | Bolt Hole Numbers - 孔径24.5: 8
FUJ5
4 x F3
4 x B4
FLJ4
8 x 鋼板 | BaseQuantities - NetSideArea: 0.153 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 下フランジ添接板_CB; 材質: SS400; 部材形状: PL; 板厚: 16.0; 重量: 8.18; 幅: 105.00; 長さ: 620.00; 孔数: 8
FLJ5
FV4
3 x 鋼板 | BaseQuantities - NetSideArea: 0.465 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 垂直補剛材_CB; 材質: SM400A; 部材形状: PL; 板厚: 11.0; 重量: 18.38; 幅: 130.00; 長さ: 1652.00
SDT1
4 x 鋼板 | BaseQuantities - NetSideArea: 0.074 m2; NetVolume: 0 m3; Steel Quantities - 部材種類: S_ダブリング_DH; 材質: SM400A; 部材形状: PL; 板厚: 14.0; 重量: 3.04; 幅: 260.00; 長さ: 260.00
3 x R4
2 x BW12-1
2 x BW12
鋼板 | BaseQuantities - NetSideArea: 1.785 m2; NetVolume: 0.01 m3; Steel Quantities - 部材種類: ブラケット; 材質: SM400A; 部材形状: PL; 板厚: 12.0; 重量: 81.74; 幅: 957.53; 長さ: 1380.00; 孔数: 16
BW12-2
鋼板 | BaseQuantities - NetSideArea: 2.474 m2; NetVolume: 0.036 m3; Steel Quantities - 部材種類: ブラケット; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 283.57; 幅: 2899.15; 長さ: 588.00; 孔数: 16
BWJ9
2 x 鋼板 | BaseQuantities - NetSideArea: 0.47 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: ブラケット添接板; 材質: SS400; 部材形状: PL; 板厚: 11.0; 重量: 19.32; 幅: 775.37; 長さ: 320.00; 孔数: 32
4 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 32
BWJF9
2 x 鋼板 | BaseQuantities - NetSideArea: 0.228 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: ブラケット添接板; 材質: SS400; 部材形状: PL; 板厚: 10.0; 重量: 8.28; 幅: 717.22; 長さ: 155.00; 孔数: 16
BWJ10
BWJF10
BU9
鋼板 | BaseQuantities - NetSideArea: 1.168 m2; NetVolume: 0.009 m3; Steel Quantities - 部材種類: 上フランジ_BR; 材質: SM400A; 部材形状: PL; 板厚: 16.0; 重量: 69.76; 幅: 400.00; 長さ: 1388.50; 孔数: 9
4 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 9
BU10
鋼板 | BaseQuantities - NetSideArea: 0.2 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 上フランジ_BR; 材質: SM490YA; 部材形状: PL; 板厚: 16.0; 重量: 11.33; 幅: 400.00; 長さ: 225.50; 孔数: 9
BL9
鋼板 | BaseQuantities - NetSideArea: 0.923 m2; NetVolume: 0.005 m3; Steel Quantities - 部材種類: 下フランジ_BR; 材質: SM400A; 部材形状: PL; 板厚: 12.0; 重量: 41.47; 幅: 300.00; 長さ: 1467.50; 孔数: 6
BL10
鋼板 | BaseQuantities - NetSideArea: 0.4 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 下フランジ_BR; 材質: SM490YA; 部材形状: PL; 板厚: 12.0; 重量: 23.36; 幅: 500.00; 長さ: 620.00; 孔数: 6
2 x BUJ9
2 x 鋼板 | BaseQuantities - NetSideArea: 0.334 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 上フランジ添接板_BR; 材質: SS400; 部材形状: PL; 板厚: 9.0; 重量: 11.30; 幅: 390.00; 長さ: 410.00; 孔数: 18
2 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 18
2 x BUJ10
2 x 鋼板 | BaseQuantities - NetSideArea: 0.1 m2; NetVolume: 0 m3; Steel Quantities - 部材種類: 上フランジ添接板_BR; 材質: SS400; 部材形状: PL; 板厚: 9.0; 重量: 3.19; 幅: 110.00; 長さ: 410.00; 孔数: 6
2 x BUJ11
2 x 鋼板 | BaseQuantities - NetSideArea: 0.183 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 上フランジ添接板_BR; 材質: SS400; 部材形状: PL; 板厚: 9.0; 重量: 6.08; 幅: 210.00; 長さ: 410.00; 孔数: 12
4 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 12
2 x BLJ9
4 x 鋼板 | BaseQuantities - NetSideArea: 0.1 m2; NetVolume: 0 m3; Steel Quantities - 部材種類: 下フランジ添接板_BR; 材質: SS400; 部材形状: PL; 板厚: 9.0; 重量: 3.19; 幅: 110.00; 長さ: 410.00; 孔数: 6
2 x BLJ10
2 x BLJ11
2 x 鋼板 | BaseQuantities - NetSideArea: 0.25 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 下フランジ添接板_BR; 材質: SS400; 部材形状: PL; 板厚: 9.0; 重量: 8.40; 幅: 290.00; 長さ: 410.00; 孔数: 12
3 x R5
2 x BW22-1
2 x BW22
鋼板 | BaseQuantities - NetSideArea: 2.483 m2; NetVolume: 0.036 m3; Steel Quantities - 部材種類: ブラケット; 材質: SM490YB; 部材形状: PL; 板厚: 32.0; 重量: 284.71; 幅: 2885.63; 長さ: 588.00; 孔数: 16
BW22-2
鋼板 | BaseQuantities - NetSideArea: 1.815 m2; NetVolume: 0.011 m3; Steel Quantities - 部材種類: ブラケット; 材質: SM400A; 部材形状: PL; 板厚: 12.0; 重量: 83.15; 幅: 889.23; 長さ: 1385.00; 孔数: 16
BWJ13
2 x 鋼板 | BaseQuantities - NetSideArea: 0.48 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: ブラケット添接板; 材質: SS400; 部材形状: PL; 板厚: 11.0; 重量: 19.75; 幅: 773.04; 長さ: 320.00; 孔数: 32
BWJF13
2 x 鋼板 | BaseQuantities - NetSideArea: 0.233 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: ブラケット添接板; 材質: SS400; 部材形状: PL; 板厚: 10.0; 重量: 8.46; 幅: 723.26; 長さ: 155.00; 孔数: 16
BWJ14
BWJF14
BU13
鋼板 | BaseQuantities - NetSideArea: 0.198 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 上フランジ_BR; 材質: SM400A; 部材形状: PL; 板厚: 16.0; 重量: 11.18; 幅: 400.00; 長さ: 222.50; 孔数: 9
BU14
鋼板 | BaseQuantities - NetSideArea: 1.167 m2; NetVolume: 0.009 m3; Steel Quantities - 部材種類: 上フランジ_BR; 材質: SM490YA; 部材形状: PL; 板厚: 16.0; 重量: 69.71; 幅: 400.00; 長さ: 1387.50; 孔数: 9
BL13
鋼板 | BaseQuantities - NetSideArea: 0.394 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 下フランジ_BR; 材質: SM490YA; 部材形状: PL; 板厚: 12.0; 重量: 23.17; 幅: 500.00; 長さ: 615.00; 孔数: 6
BL14
鋼板 | BaseQuantities - NetSideArea: 0.91 m2; NetVolume: 0.005 m3; Steel Quantities - 部材種類: 下フランジ_BR; 材質: SM400A; 部材形状: PL; 板厚: 12.0; 重量: 40.89; 幅: 300.00; 長さ: 1447.00; 孔数: 6
4 x C17
FW117-2
FW117
2 x 鋼板 | BaseQuantities - NetSideArea: 11.546 m2; NetVolume: 0.106 m3; Steel Quantities - 部材種類: 横桁; 材質: SS400; 部材形状: H-800.0*300.0*14.0*26.0; 重量: 845.44; 幅: 800.00; 長さ: 4084.27; 孔数: 60
12 x Bolt孔 | Bolt Hole Numbers - 孔径24.5: 32; 孔径26.5: 28
2 x FW117-1
12 x FWJ9
48 x 鋼板 | BaseQuantities - NetSideArea: 0.421 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 横桁添接板; 材質: SS400; 部材形状: PL; 板厚: 13.0; 重量: 20.25; 幅: 628.07; 長さ: 320.00; 孔数: 28
48 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 28
12 x FWJF17
48 x 鋼板 | BaseQuantities - NetSideArea: 0.203 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 横桁添接板; 材質: SS400; 部材形状: PL; 板厚: 7.0; 重量: 5.28; 幅: 623.95; 長さ: 155.00; 孔数: 14
48 x Bolt孔 | Bolt Hole Numbers - 孔径26.5: 14
12 x FWJ10
12 x FWJF18
12 x FWJF19
12 x FWJF20
12 x FU35
24 x 鋼板 | BaseQuantities - NetSideArea: 0.16 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 上フランジ_CB; 材質: SM400A; 部材形状: PL; 板厚: 26.0; 重量: 15.77; 幅: 281.00; 長さ: 335.00; 孔数: 4
96 x Bolt孔 | Bolt Hole Numbers - 孔径24.5: 4
12 x FU34
FW117-3
12 x FU37
24 x 鋼板 | BaseQuantities - NetSideArea: 0.16 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 上フランジ_CB; 材質: SM400A; 部材形状: PL; 板厚: 26.0; 重量: 15.79; 幅: 281.00; 長さ: 335.50; 孔数: 4
12 x FU36
12 x FL35
24 x 鋼板 | BaseQuantities - NetSideArea: 0.16 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 下フランジ_CB; 材質: SM400A; 部材形状: PL; 板厚: 26.0; 重量: 15.77; 幅: 281.00; 長さ: 335.00; 孔数: 4
12 x FL34
12 x FL37
24 x 鋼板 | BaseQuantities - NetSideArea: 0.16 m2; NetVolume: 0.002 m3; Steel Quantities - 部材種類: 下フランジ_CB; 材質: SM400A; 部材形状: PL; 板厚: 26.0; 重量: 15.75; 幅: 281.00; 長さ: 334.50; 孔数: 4
12 x FL36
12 x FUJ20
24 x 鋼板 | BaseQuantities - NetSideArea: 0.346 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 上フランジ添接板_CB; 材質: SS400; 部材形状: PL; 板厚: 19.0; 重量: 22.89; 幅: 380.00; 長さ: 470.00; 孔数: 16
48 x Bolt孔 | Bolt Hole Numbers - 孔径24.5: 16
12 x FUJ21
48 x 鋼板 | BaseQuantities - NetSideArea: 0.157 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 上フランジ添接板_CB; 材質: SS400; 部材形状: PL; 板厚: 19.0; 重量: 9.93; 幅: 155.00; 長さ: 470.00; 孔数: 8
12 x FUJ22
12 x FUJ23
12 x FUJ24
12 x FUJ25
12 x FLJ20
48 x 鋼板 | BaseQuantities - NetSideArea: 0.157 m2; NetVolume: 0.001 m3; Steel Quantities - 部材種類: 下フランジ添接板_CB; 材質: SS400; 部材形状: PL; 板厚: 19.0; 重量: 9.93; 幅: 155.00; 長さ: 470.00; 孔数: 8
12 x FLJ21
12 x FLJ22
24 x 鋼板 | BaseQuantities - NetSideArea: 0.346 m2; NetVolume: 0.003 m3; Steel Quantities - 部材種類: 下フランジ添接板_CB; 材質: SS400; 部材形状: PL; 板厚: 19.0; 重量: 22.89; 幅: 380.00; 長さ: 470.00; 孔数: 16
12 x FLJ23
12 x FLJ24
12 x FLJ25
4 x C18
FW118-2
FW118
鋼板 | BaseQuantities - NetSideArea: 11.549 m2; NetVolume: 0.106 m3; Steel Quantities - 部材種類: 横桁; 材質: SS400; 部材形状: H-800.0*300.0*14.0*26.0; 重量: 845.65; 幅: 800.00; 長さ: 4085.27; 孔数: 60
2 x FW118-1
FW118-3
4 x C19
FW119-2
FW119
3 x 鋼板 | BaseQuantities - NetSideArea: 11.554 m2; NetVolume: 0.106 m3; Steel Quantities - 部材種類: 横桁; 材質: SS400; 部材形状: H-800.0*300.0*14.0*26.0; 重量: 846.06; 幅: 800.00; 長さ: 4087.27; 孔数: 60
2 x FW119-1
FW119-3
4 x C20
FW120-2
FW120
4 x 鋼板 | BaseQuantities - NetSideArea: 11.555 m2; NetVolume: 0.106 m3; Steel Quantities - 部材種類: 横桁; 材質: SS400; 部材形状: H-800.0*300.0*14.0*26.0; 重量: 846.06; 幅: 800.00; 長さ: 4087.27; 孔数: 60
2 x FW120-1
FW120-3
4 x C21
FW121-2
FW121
2 x FW121-1
FW121-3
4 x C22
FW122-2
FW122
2 x FW122-1
FW122-3
4 x C23
FW123-2
FW123
鋼板 | BaseQuantities - NetSideArea: 11.548 m2; NetVolume: 0.106 m3; Steel Quantities - 部材種類: 横桁; 材質: SS400; 部材形状: H-800.0*300.0*14.0*26.0; 重量: 845.55; 幅: 800.00; 長さ: 4084.77; 孔数: 60
2 x FW123-1
FW123-3
4 x C24
FW124-2
FW124
2 x FW124-1
FW124-3
4 x C25
FW125-2
FW125
鋼板 | BaseQuantities - NetSideArea: 11.552 m2; NetVolume: 0.106 m3; Steel Quantities - 部材種類: 横桁; 材質: SS400; 部材形状: H-800.0*300.0*14.0*26.0; 重量: 845.86; 幅: 800.00; 長さ: 4086.27; 孔数: 60
2 x FW125-1
FW125-3
4 x C26
FW126-2
FW126
2 x FW126-1
FW126-3
4 x C27
FW127-2
FW127
2 x FW127-1
FW127-3
4 x C28
FW128-2
FW128
2 x FW128-1
FW128-3
